# Keil uVision project led.uvproj, settings and files
target led (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: led
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=3 wLevel=2
  c include: ..\NUC100_120BSPv3.00.002\Library\CMSIS\Include;..\NUC100_120BSPv3.00.002\Library\Device\Nuvoton\NUC100Series\Include;..\NUC100_120BSPv3.00.002\Library\StdDriver\inc;..\common
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --first='startup_NUC100Series.o(RESET)'
  group cmsis
    ../NUC100_120BSPv3.00.002/Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../NUC100_120BSPv3.00.002/Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group src
    ./: main.c
    ../common/: nuc100.c
  group lib
    ../NUC100_120BSPv3.00.002/Library/StdDriver/src/: clk.c gpio.c sys.c
